Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_123/temp/tmp_7916_128_CAi7B/format_1/0080.0249(architecture_400).ifc
Time: 2025-05-05T08:02:29
Made in: PARTsolutions

# IfcProject, 0080.0249
Description: Semi-centrifugal duct fan

# IfcDiscreteAccessory, 0080.0249(architecture,400)
In: BUILDING
Description: 0080.0249
Pset_ManufacturerTypeInformation - Manufacturer: MAICO; ArticleNumber: 0080.0249
ePset_PARTsolutions - NB: 0080.0249(architecture,400); NN: ERM 25 Ex e; NT: Semi-centrifugal duct fan; NBSYN: $ARTNR.($LODDEST.,$LODLEVEL.); LINA: 0080.0249; CATALOG: MAICO; ARTNR: 0080.0249; CTN: 84145935; LODDEST: Architecture; LODLEVEL: 400; FV: 870; DZ: 2.820; LRT: semi-radial; DS: -; S: Alternating current; B: 230; N: 50; NL: 300; C: 0.93; INOM: 1.4; IMAU: 1.40; SZ: IP 54; WK: F; NZ: 3 / 1.5; EO: vertical / horizontal; MG: Synthetic material; F: Signal black, similar to RAL 9004; G: 7.4; NW: 250; BR: 340; H: 337.5; T: 232; EXAR: Ex II 2 G; EXN: Ex e IIB + H2 T3 Gb; TAUT: -20 ɤ Ta ɤ +50; IAIN: 3.5; ZTE: 19; BA: S1; EG: EX5 01 06 39250 004; TK: T3; KKS: 16/280; WVI: 155; V: 1; SR: C; GE: 4012799802495; PROCUREWEBLINK: https://p.caden.as/maico/0080.0249; PROCUREDATALASTUPDATE: 2025-04-25T13:37:59.474896733+01:00; PROCURELINK: p.caden.as/maico/0080.0249
