Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_125/temp/tmp_7400_338_JiX3h/format_0/0080.0288(architecture_400).ifc
Time: 2025-05-05T07:59:29
Made in: PARTsolutions

# IfcProject, 0080.0288
Description: Semi-centrifugal duct fan

# IfcDiscreteAccessory, 0080.0288(architecture,400)
In: BUILDING
Description: 0080.0288
Pset_ManufacturerTypeInformation - Manufacturer: MAICO; ArticleNumber: 0080.0288
ePset_PARTsolutions - NB: 0080.0288(architecture,400); NN: ERM 22 Ex e; NT: Semi-centrifugal duct fan; NBSYN: $ARTNR.($LODDEST.,$LODLEVEL.); LINA: 0080.0288; CATALOG: MAICO; ARTNR: 0080.0288; CTN: 84145935; LODDEST: Architecture; LODLEVEL: 400; FV: 560; DZ: 2.860; LRT: semi-radial; DS: -; S: Alternating current; B: 230; N: 50; NL: 200; C: 0.92; INOM: 0.92; IMAU: 0.92; SZ: IP 54; WK: B; NZ: 3 / 1.5; EO: vertical / horizontal; MG: Synthetic material; F: Signal black, similar to RAL 9004; G: 6.5; NW: 200; BR: 306; H: 310; T: 269; EXAR: Ex II 2 G; EXN: Ex e IIB + H2 T3 Gb; TAUT: -20 ɤ Ta ɤ +50; IAIN: 3.1; ZTE: 30; BA: S1; EG: EX5 01 06 39250 005; TK: T3; KKS: 12/280; WVI: 130; V: 1; SR: C; GE: 4012799802884; PROCUREWEBLINK: https://p.caden.as/maico/0080.0288; PROCUREDATALASTUPDATE: 2025-04-25T13:37:59.334294833+01:00; PROCURELINK: p.caden.as/maico/0080.0288
