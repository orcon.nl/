Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: p:/temp/worker_COMMON_126/temp/tmp_5904_161_dP6Zp/format_0/0080.0290(architecture_400).ifc
Time: 2025-05-05T07:55:29
Made in: PARTsolutions

# IfcProject, 0080.0290
Description: Semi-centrifugal duct fan

# IfcDiscreteAccessory, 0080.0290(architecture,400)
In: BUILDING
Description: 0080.0290
Pset_ManufacturerTypeInformation - Manufacturer: MAICO; ArticleNumber: 0080.0290
ePset_PARTsolutions - NB: 0080.0290(architecture,400); NN: ERM 18 Ex e; NT: Semi-centrifugal duct fan; NBSYN: $ARTNR.($LODDEST.,$LODLEVEL.); LINA: 0080.0290; CATALOG: MAICO; ARTNR: 0080.0290; CTN: 84145935; LODDEST: Architecture; LODLEVEL: 400; FV: 310; DZ: 2.780; LRT: semi-radial; DS: -; S: Alternating current; B: 230; N: 50; NL: 50; C: 0.9; INOM: 0.25; IMAU: 0.25; SZ: IP 54; WK: B; NZ: 3 / 1.5; EO: vertical / horizontal; MG: Synthetic material; F: Signal black, similar to RAL 9004; G: 3.6; NW: 180; BR: 262; H: 252; T: 187; EXAR: Ex II 2 G; EXN: Ex e IIB + H2 T4 Gb; TAUT: -20 ɤ Ta ɤ +50; IAIN: 2.5; ZTE: 50; BA: S1; EG: EX5 01 10 39250 006; TK: T4; KKS: 3/280; WVI: 130; V: 1; SR: C; GE: 4012799802907; PROCUREWEBLINK: https://p.caden.as/maico/0080.0290; PROCUREDATALASTUPDATE: 2025-04-25T13:37:59.19251388+01:00; PROCURELINK: p.caden.as/maico/0080.0290
